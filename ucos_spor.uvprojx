# Keil uVision project ucos_spor.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F401CDUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bw_ucos_spor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Start;.\FWLib\inc;.\System\uart;.\System\delay;.\System\gpiof;.\System\sys;.\System\dma;.\UCOSIII\uC-LIB;.\UCOSIII\uC-CPU;.\UCOSIII\uCOS-III;.\UCOSIII\UCOS_BSP;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Start
    ./Start/: startup_stm32f401xx.s system_stm32f4xx.c
  group User
    ./User/: main.c
  group FWLib
    ./FWLib/src/: stm32f4xx_usart.c misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_dma.c
  group System
    ./System/delay/: delay.c
    ./System/gpiof/: gpiof.c
    ./System/uart/: uart.c
    ./System/dma/: dma.c
  group UCOSIII-BSP
    ./UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII-CPU
    ./UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ./UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII-LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII-CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII-PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group UCOSIII-CONFIG
    ./UCOSIII/uCOS_CONFIG/: os_app_hooks.c
